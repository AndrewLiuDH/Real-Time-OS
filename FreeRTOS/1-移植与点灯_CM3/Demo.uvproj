# Keil uVision project Demo.uvproj, settings and files
target Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS\DeviceSupport\ST\STM32F10x;.\CMSIS\CoreSupport;.\FWlib\inc;.\user;.\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c
  group USER
    ./user/: main.c delay.c stm32f10x_it.c led.c usart.c nrf24l01.c
  group SRC
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
    ./FWlib/src/: stm32f10x_usart.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
