# Keil uVision project Demo.uvproj, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sdio_flash
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_USED=1
  c include: .\user;.\FWlib\inc;.\CORE;.\user\ff12a;.\uCOSIII\uC-bsp;.\uCOSIII\uC-LIB;.\uCOSIII\uCOS-III\Ports;.\uCOSIII\uCOS-III\Source;.\uCOSIII\uC-CPU;.\uCOSIII\uC-config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FWlib
    ./FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group user
    ./user/: usart.c delay.c led.c main.c stm32f4xx_it.c exit.c
  group uC-bsp
    ./uCOSIII/uC-bsp/: bsp.c
  group uC-config
    ./uCOSIII/uC-config/: os_app_hooks.c
  group uC-port
    ./uCOSIII/uCOS-III/Ports/: os_cpu_a.asm os_cpu_c.c
  group uC-lib
    ./uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./uCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC-cpu
    ./uCOSIII/uC-CPU/: cpu_core.c cpu_c.c cpu_a.asm
  group uC-core
    ./uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
