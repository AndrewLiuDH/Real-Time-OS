# Keil uVision project Demo.uvproj, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sdio_flash
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4xx
  c include: .\user;.\FWlib\inc;.\CORE;.\user\ff12a;.\Modbus\BARE\port;.\Modbus\include;.\Modbus\rtu
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./CORE/: startup_stm32f40xx.s system_stm32f4xx.c
  group FWlib
    ./FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group user
    ./user/: usart.c delay.c led.c main.c stm32f4xx_it.c sys.h
  group Modbus-port
    ./Modbus/BARE/port/: portevent.c portserial.c porttimer.c port.c
  group Modbus-rtu
    ./Modbus/rtu/: mbcrc.c mbrtu.c
  group Modbus-func
    ./Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./Modbus/: mb.c
