# Keil uVision project usart.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sdio_flash
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\user;.\FWlib\inc;.\CORE;.\lwip-1.4.1\src\include\ipv4;.\lwip-1.4.1\src\include\lwip;.\lwip-1.4.1\src\include\netif;.\lwip-1.4.1\port\arch;.\lwip-1.4.1\port\Standalone;.\user\ethernet;.\lwip-1.4.1\src\include;.\lwip-1.4.1\port;.\user\ff09
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: main.c delay.c usart.c led.c stm32f4xx_it.c sdio_flash.c key.c
    ./user/ethernet/: tftpserver.c tftputils.c
  group cmsis
    ./CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FWlib
    ./FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group lwip-port
    ./lwip-1.4.1/port/Standalone/: ethernetif.c
    ./user/ethernet/: stm32f4x7_eth.c netconf.c lan8720a.c
  group lwip-core
    ./lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip-api
    ./lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-netif
    ./lwip-1.4.1/src/netif/: etharp.c
  group ff09
    ./user/ff12a/: diskio.c
    ./user/ff09/: ff.c
