# Keil uVision project Demo.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sdio_flash
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\user;.\FWlib\inc;.\CORE;.\user\ff12a;.\Emwin\Config;.\Emwin\inc;.\Emwin\Demo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FWlib
    ./FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group user
    ./user/: main.c usart.c delay.c led.c stm32f4xx_it.c lcd9341.c display.c sys.c
  group emwin-config
    ./Emwin/OS/: GUI_X.c
    ./Emwin/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUIDRV_Template.c
    ./Emwin/Lib/: STemWin532_CM4_Keil.lib
